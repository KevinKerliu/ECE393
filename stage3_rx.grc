options:
  parameters:
    author: root
    generate_options: qt_gui
    id: stage3_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: costas_loop_bw
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '1'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Frequency Offset
    orient: Qt.Horizontal
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: freq_sink_bw
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '5'
    value: '1'
    widget: counter
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Noise Voltage
    orient: Qt.Vertical
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0001'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {state: disabled}
- name: taps_0
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Timing Offset
    orient: Qt.Horizontal
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: 'Time: BW'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '0.01'
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: costas_loop_bw*3.1415/100
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '0'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps*1.001
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '10000'
    type: '0'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from numpy import random
      #import matplotlib.pyplot as plt

      class QLearning(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def cost(self,SINR_ij,SINR_th):
              return (SINR_ij - SINR_th)**2

          # SINR_X_UL
          def SINR_X_UL(self,P_SU): 
              P_PU = 1
              return P_PU - np.sum(P_SU) # should be subtraction

          # p_mat Function
          def create_p_mat(self,current_states,omitted_state,P):
              p_vec = np.zeros(len(current_states))
              for i in range(0,len(current_states)):
                  p_vec[i] = P[current_states[i]]
              p_mat = np.zeros((len(P),len(current_states)))
              for i in range(0,len(P)):
                  p_mat[i,:] = p_vec
              p_mat[:,omitted_state] = P
              return p_mat

          # Final State Function
          def useQ(self,Q,starting_state,SU):
              final_state = starting_state
              for i in range(0,10):
                 min_Q = np.min(Q[final_state,:,SU])
                 possible = np.where(Q[final_state,:,SU] == min_Q)
                 action = possible[0][random.randint(len(possible[0]))]
                 if (Q[final_state,action,SU] == Q.min()):
                     return action
                 else:
                     return action

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='QLearning2',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              # Hyper-parameters
              self.alpha = 0.5
              self.gamma = 0.9
              self.epsilon = 0.1
              self.n_iterations = 3000
              self.SINR_th = 23 #15 to 20
              self.num_SU = 1
              self.P = [-80,-50,-30,10.1,29.8]
              self.n_states = len(P)

              self.Q = np.zeros((self.n_states,self.n_states,self.num_SU))
              self.Q_iterations = np.zeros((self.n_states,self.n_states,self.n_iterations+1,self.num_SU))

              # SINR Vector
              self.SINR_vec = np.zeros(self.n_states)
              for i in range (0,self.n_states):
                  self.SINR_vec[i] = self.SINR_X_UL(P[i])

              # Cost Vector
              # self.cost_vec = self.cost(self.SINR_vec,self.SINR_th) # (|Difference|)
              self.cost_vec = self.cost(self.SINR_vec,self.SINR_th) # (Difference^2)
              # self.cost_vec = self.cost(self.SINR_vec,self.SINR_th) # (Difference^4)

              # Reward Matrix
              self.R = np.zeros((self.n_states,self.n_states,self.num_SU));

              # Q-Learning Algorithm
              state = random.randint(len(self.R[1,:,1]), size=self.num_SU);
              action = np.zeros(self.num_SU);
              for i in range(0,self.n_iterations):
                  for k in range(0,self.num_SU):
                      # Create R matrix holding other states constant
                      p_mat = self.create_p_mat(state,k,self.P);
                      for j in range(0,self.n_states):
                          self.SINR_vec[j] = self.SINR_X_UL(p_mat[j,:]);

                      self.cost_vec = self.cost(self.SINR_vec,self.SINR_th);
                      for j in range(0,self.n_states):
                          self.R[j,:,k] = self.cost_vec;
                
                      # Random Greedy Algorithm choice for next Action
                      random_greedy = random.rand(1);
                      if random_greedy < epsilon:
                          action[k] = random.randint(len(self.R[1,:,1]));
                      else:
                          self.Q[np.isnan(self.Q)] = 0
                          min_Q = np.min(self.Q[state[k],:,k]);
                          possible = np.where(self.Q[state[k],:,k] == min_Q)
                          action[k] =  possible[0][random.randint(len(possible[0]))];

                
                      # Calculating Q and Stochastic Gradiant Descent 
                      min_next_Q = np.min(self.Q[int(action[k]),:,k]);
                      discount = self.gamma*min_next_Q;
                      delta_Q = self.alpha*(self.R[state[k],int(action[k]),k] + discount - self.Q[state[k],int(action[k]),k]);
                      self.Q[state[k],int(action[k]),k] = self.Q[state[k],int(action[k]),k] + delta_Q;
                      self.Q_iterations[:,:,i+1,k] = self.Q[:,:,k];
                      state[k] = action[k];


              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '1'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.5'
    gui_hint: 1,2,1,2
    label1: Timing Recov.
    name: ''
    size: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: freq_sink_bw*samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: '4000000'
    center_freq0: '3000000000'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '20'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', epy_block_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [digital_probe_mpsk_snr_est_c_0, noise, blocks_message_debug_0, print]
- [digital_probe_mpsk_snr_est_c_0, signal, blocks_message_debug_0, print]
- [digital_probe_mpsk_snr_est_c_0, snr, blocks_message_debug_0, print]
- [digital_probe_mpsk_snr_est_c_0, snr, blocks_message_debug_0, store]
- [epy_block_1, '0', qtgui_number_sink_0, '0']
- [uhd_usrp_source_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [uhd_usrp_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [uhd_usrp_source_0, '0', digital_probe_mpsk_snr_est_c_0, '0']

metadata:
  file_format: 1
